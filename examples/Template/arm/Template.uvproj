# Keil uVision project Template.uvproj, settings and files
target Release (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c include: ..\..\..\include
  memory RVCT4: ROM 0x34000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\..\..\lib\juma_sdk.sct
  group User
    ../: user.c
  group Lib
    ../../../lib/: juma_sdk.lib
